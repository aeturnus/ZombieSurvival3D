# Keil uVision project MainController.uvproj, settings and files
target Lab8 (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: Lab8
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s LCD.s Print.s MainController.c Interface1.c Music.c
    ../: ST7735.c TExaS.c random.s
    ../../brandonware/: BrandonBufferManager.c BrandonMath.c BrandonTypes.c BrandonRaycaster.c BrandonPhysics.c BrandonFIFO.c
    ../../drivers/: SysTick.c Timer0.c Timer1.c UART.c
  group Object code
    ./: texas.o
